# Keil uVision project DS134.uvproj, settings and files
target DS132 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: DS134 +hex
  link misc: REMOVEUNUSED
  group USER
    ./USER/: main.c USB_CDC_drive.c LED_drive.c KEY_drive.c SYS_drive.c COMMON_drive.c DS134_Color_drive.c sw_iic.c
  group Library
    ./Library/: STC32G_Delay.c STC32G_GPIO.c stc_usb_cdc_32.LIB STC32G_NVIC.c STC32G_I2C.c
