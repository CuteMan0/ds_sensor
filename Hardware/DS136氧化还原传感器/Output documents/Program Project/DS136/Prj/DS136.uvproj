# Keil uVision project DS136.uvproj, settings and files
target orp (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: DS136 +hex
  link misc: REMOVEUNUSED
  group App
    ../: main.c
  group Driver
    ../Driver/: ADC_drive.c TIM_drive.c LED_drive.c USB_CDC_drive.c DS136_orp_drive.c
  group Library
    ../Driver/Library/: STC32G_ADC.c STC32G_GPIO.c stc_usb_cdc_32.LIB STC32G_Timer.c STC32G_Timer_Isr.c STC32G_NVIC.c
  group Tool
    ../Driver/Tool/: log.c task_scheduler.c avg_filter.c
