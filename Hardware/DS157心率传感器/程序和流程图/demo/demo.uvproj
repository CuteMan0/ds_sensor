# Keil uVision project demo.uvproj, settings and files
target demo (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: demo +hex
  link misc: REMOVEUNUSED, NOOVERLAY
  group User Sources
    ./Sources/driver/: sw_iic.c max30102.c fft.c
  group AiCube
    ./Sources/: main.c port.c clock.c usblib.c
    ./Sources/lib/: stc_usb_cdc_32g.lib AI8051U_32_TFPU.LIB
