# Keil uVision project DS159.uvproj, settings and files
target BreathRate (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: DS159BreathRate +hex
  link misc: REMOVEUNUSED
  group App
    ../: main.c
  group Driver
    ../Driver/: ADC_drive.c LED_drive.c USB_CDC_drive.c
  group Library
    ../Driver/Library/: STC32G_ADC.c STC32G_GPIO.c STC32G_Timer.c STC32G_Timer_Isr.c stc_usb_cdc_32.LIB
  group Tool
    ../Driver/Tool/: task_scheduler.c fft.c log.c
