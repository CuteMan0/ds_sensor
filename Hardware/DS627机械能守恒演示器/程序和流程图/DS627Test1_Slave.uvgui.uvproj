# Keil uVision project DS627Test1_Slave.uvgui.uvproj, settings and files
target DS109Test1_Slave (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: DS627 +hex
  link misc: REMOVEUNUSED
  group USER
    ./USER/: main.c USB_CDC_drive.c LED_drive.c KEY_drive.c COMMON_drive.c SYS_drive.c ds627_MECons_drive.c avg_filter.c
  group Library
    ./Library/: STC32G_Delay.c STC32G_GPIO.c STC32G_NVIC.c stc_usb_cdc_32.LIB STC32G_Exti.c STC32G_Exti_Isr.c STC32G_Timer.c
