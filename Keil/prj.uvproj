# Keil uVision project prj.uvproj, settings and files
target files (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: prj +hex
  link misc: REMOVEUNUSED
  group App
    ../App/: main.c task.c
  group Bsp
    ../Bsp/: bsp_ds18b20.c bsp_max30102.c bsp_mlx90614.c bsp_ntc_10k_b3950.c bsp_sht40.c bsp_tcs3400.c ds112_fir_meter.c ds131_ph_meter.c ds132_ec_meter.c ds133_multi_ec_meter.c ds135_tur_meter.c ds136_orp_meter.c ds137_so2_meter.c ds138_airC2H6O_meter.c ds139_o2_meter.c ds141_co2_meter.c ds144_do_meter.c ds145_dco2_meter.c ds151_soil_temp_meter.c ds153_h2_meter.c ds158_ecg_meter.c ds160_no2_meter.c ds161_co_meter.c ds162_ch4_meter.c ds163_nh3_meter.c ds164_cl2_meter.c ds165_170_ise_meter.c ds172_titration_meter.c
  group Driver
    ../Driver/: adc_drive.c key_drive.c led_drive.c sw_iic_drive.c tim_drive.c
  group Library
    ../Library/: STC32G_ADC.c STC32G_ADC_Isr.c STC32G_CAN.c STC32G_CAN_Isr.c STC32G_Clock.c STC32G_Compare.c STC32G_Compare_Isr.c STC32G_Delay.c STC32G_DMA.c STC32G_DMA_Isr.c STC32G_EEPROM.c STC32G_Exti.c STC32G_Exti_Isr.c STC32G_GPIO.c STC32G_GPIO_Isr.c STC32G_I2C.c STC32G_I2C_Isr.c STC32G_LCM.c STC32G_LCM_Isr.c STC32G_LIN.c STC32G_LIN_Isr.c STC32G_NVIC.c STC32G_PWM.c STC32G_PWM_Isr.c STC32G_RTC.c STC32G_RTC_Isr.c STC32G_Soft_I2C.c STC32G_Soft_UART.c STC32G_SPI.c STC32G_SPI_Isr.c STC32G_Timer.c STC32G_Timer_Isr.c STC32G_UART.c STC32G_UART_Isr.c STC32G_USART_LIN.c STC32G_WDT.c stc_usb_cdc_32g.LIB
  group Tool
    ../Tool/: filter.c task_scheduler.c fft.c lut.c
